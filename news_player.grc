options:
  parameters:
    author: Joel Lehtonen
    generate_options: no_gui
    id: news_player
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: News player
  states: {}

blocks:
- name: deviation
  id: variable
  parameters:
    value: '90000'
  states: {}
- name: oversample
  id: variable
  parameters:
    value: '8'
  states: {}
- name: redsea_rate
  id: variable
  parameters:
    value: '171000'
  states: {}
- name: analog_quadrature_demod_cf_0
  id: analog_quadrature_demod_cf
  parameters:
    gain: redsea_rate/(2*math.pi*deviation)
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: '"pulse"'
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio rate in Hz
    short_id: r
    type: intx
    value: '48000'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    device_name: audio_device
    ok_to_block: 'False'
    samp_rate: audio_rate
  states: {}
- name: bb_gain
  id: parameter
  parameters:
    label: BB gain
    short_id: b
    type: intx
    value: '20'
  states: {}
- name: blocks_float_to_short_0
  id: blocks_float_to_short
  parameters:
    scale: 2**15
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: device
  id: parameter
  parameters:
    label: Device string
    short_id: d
    type: str
    value: '""'
  states: {}
- name: fm_deemph
  id: analog_fm_deemph
  parameters:
    samp_rate: redsea_rate
    tau: '50e-6'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: 2*redsea_rate
    decim: oversample
    samp_rate: oversample*redsea_rate
    taps: firdes.complex_band_pass(1,oversample*redsea_rate,-deviation,deviation, 2000)
    type: ccc
  states: {}
- name: frequency
  id: parameter
  parameters:
    label: Frequency in MHz
    short_id: f
    type: eng_float
    value: '100'
  states: {}
- name: if_gain
  id: parameter
  parameters:
    label: IF gain
    short_id: i
    type: intx
    value: '20'
  states: {}
- name: muter
  id: blocks_mute_xx
  parameters:
    mute: 'True'
    type: float
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    args: device
    bb_gain0: bb_gain
    freq0: 1e6*frequency-2*redsea_rate
    gain0: rf_gain
    gain_mode0: 'False'
    if_gain0: if_gain
    sample_rate: oversample*redsea_rate
    sync: pc_clock
    type: fc32
  states: {}
- name: pty
  id: parameter
  parameters:
    label: PTY to play
    short_id: p
    type: str
    value: '"News"'
  states: {}
- name: pty_mute
  id: epy_block
  parameters:
    _source_code: |
      """
      PTY unmuter block
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import sys

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """
          Send unmute message when PTY starts and mute when it ends. Also,
          stop the top block after given PTY if stop_after is enabled and
          top_block is set to self in grc.
          """

          def __init__(self, top_block=None, target_pty="News", stop_after=True):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='PTY unmuter',   # will show up in GRC
                  in_sig=[],
                  out_sig=[]
              )
              self.message_port_register_in(pmt.intern("pty"))
              self.message_port_register_out(pmt.intern("mute"))
              self.set_msg_handler(pmt.intern('pty'), self.pty_msg)

              # if an attribute with the same name as a parameter is found,
              # a callback is registered (properties work, too).
              self.target_pty = target_pty
              self.die_state = 0
              self.top_block = top_block
              self.stop_after = stop_after

          def pty_msg(self, new_pty):
              print(str(new_pty))
              mute = str(new_pty) != self.target_pty
              self.message_port_pub(pmt.intern('mute'), pmt.from_bool(mute))

              if (not mute and self.die_state == 0) or (mute and self.die_state == 1):
                  self.die_state += 1
                  if self.die_state == 2:
                      if self.top_block is not None and (self.stop_after != 0 or self.stop_after == True):
                          self.top_block.stop()
    stop_after: stop_after
    target_pty: pty
    top_block: self
  states: {}
- name: redsea
  id: epy_block
  parameters:
    _source_code: |
      """
      Redsea integration
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import subprocess
      import select
      import json

      class debounce():
          """Debounce for a value. Value has to be present in given number of
             successive packets before it's considered stable."""

          def __init__(self, streak=3):
              self.streak = streak
              self.current = None
              self.pending = None

          def got(self, value):
              # No data in input, ignore
              if value is None:
                  return None

              # If got current value, reset pending value
              if value == self.current:
                  self.pending = None
                  return None

              # If value is not pending, make it one
              if value != self.pending:
                  self.pending = value
                  self.tries = self.streak

              # Check if target reached
              self.tries -= 1
              if self.tries == 0:
                  self.current = self.pending
                  self.pending = None
                  return self.current

              # Nothing changed
              return None

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Redsea RDS decoder integration"""

          def __init__(self, command="redsea"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='RDS parser',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[]
              )
              self.message_port_register_out(pmt.intern("pty"))
              
              # Fork process later because otherwise gnuradio does it too early
              self.redsea = None
              self.command = command
              self.pty_debounce = debounce()

          def work(self, input_items, output_items):
              """Throw data to Red Sea"""
              if self.redsea is None:
                  self.redsea = subprocess.Popen([self.command], bufsize=0, stdin=subprocess.PIPE, stdout=subprocess.PIPE)

              # Receive JSON if any
              while True:
                  # Selecting both reading and writing but ignoring output
                  # because we already know it's ready for writing when we
                  # can't read no more. In short, we prioritize reading RDS
                  # data if it's available.
                  reading, _, _ = select.select([self.redsea.stdout] , [self.redsea.stdin], [])
                  if (reading == []):
                      break

                  rds = json.loads(self.redsea.stdout.readline())
                  if "prog_type" in rds:
                      new_pty = self.pty_debounce.got(rds["prog_type"])
                      if new_pty is not None:
                          # If PTY really changes, report it
                          self.message_port_pub(pmt.intern('pty'), pmt.intern(new_pty))

              # Send data to Redsea
              self.redsea.stdin.write(input_items[0].tobytes())

              # Report consumed items
              return len(input_items[0])
    command: redsea_path
  states: {}
- name: redsea_path
  id: parameter
  parameters:
    label: Path to Redsea
    short_id: R
    type: str
    value: '"./redsea"'
  states: {}
- name: resample_to_audio
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: redsea_rate/audio_rate
    type: float
  states: {}
- name: rf_gain
  id: parameter
  parameters:
    label: RF gain
    short_id: g
    type: intx
    value: '30'
  states: {}
- name: stop_after
  id: parameter
  parameters:
    label: Exit after given PTY ends
    short_id: s
    type: intx
    value: '1'
  states: {}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: mpx
  states: {}
- name: virtual_sink_1
  id: virtual_sink
  parameters:
    stream_id: mute
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: mpx
  states: {}
- name: virtual_source_1
  id: virtual_source
  parameters:
    stream_id: mute
  states: {}
- name: volume
  id: parameter
  parameters:
    label: Audio volume (0..1)
    short_id: V
    type: eng_float
    value: '1'
  states: {}

connections:
- [analog_quadrature_demod_cf_0, '0', virtual_sink_0, '0']
- [blocks_float_to_short_0, '0', redsea, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink, '0']
- [fm_deemph, '0', muter, '0']
- [freq_xlating_fir_filter_xxx_0, '0', analog_quadrature_demod_cf_0, '0']
- [muter, '0', resample_to_audio, '0']
- [osmosdr_source_0, '0', freq_xlating_fir_filter_xxx_0, '0']
- [pty_mute, mute, virtual_sink_1, '0']
- [redsea, pty, pty_mute, pty]
- [resample_to_audio, '0', blocks_multiply_const_vxx_0, '0']
- [virtual_source_0, '0', blocks_float_to_short_0, '0']
- [virtual_source_0, '0', fm_deemph, '0']
- [virtual_source_1, '0', muter, set_mute]

metadata:
  file_format: 1
