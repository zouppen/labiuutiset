options:
  parameters:
    author: Joel Lehtonen
    generate_options: no_gui
    id: news_player
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: News player
  states: {}

blocks:
- name: redsea_rate
  id: variable
  parameters:
    value: '171000'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: pulse
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio rate in Hz
    short_id: r
    type: intx
    value: '48000'
  states: {}
- name: audio_sink
  id: audio_sink
  parameters:
    device_name: audio_device
    ok_to_block: 'False'
    samp_rate: '48000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/joell/projektit/labiuutiset/poista.raw
    repeat: 'True'
    type: short
  states: {}
- name: fd_source
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: short
  states: {state: disabled}
- name: fm_deemph
  id: analog_fm_deemph
  parameters:
    samp_rate: redsea_rate
    tau: '50e-6'
  states: {}
- name: muter
  id: blocks_mute_xx
  parameters:
    mute: 'True'
    type: float
  states: {}
- name: pty
  id: parameter
  parameters:
    label: PTY to play
    short_id: p
    type: str
    value: News
  states: {}
- name: pty_mute
  id: epy_block
  parameters:
    _source_code: "\"\"\"\nSend mute and kill signals based on messages status\n\"\"\"\n\nimport numpy as np\nfrom gnuradio import gr\nimport pmt\nimport sys\n\nclass blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block\n    \"\"\"Embedded Python Block example - a simple multiply const\"\"\"\n\n    def __init__(self, top_block=None, target_pty=\"News\", stop_after=True):  # only default arguments here\n        \"\"\"arguments to this function show up as parameters in GRC\"\"\"\n        gr.sync_block.__init__(\n            self,\n            name='PTY unmuter',   # will show up in GRC\n            in_sig=[],\n            out_sig=[]\n        )\n        self.message_port_register_in(pmt.intern(\"pty\"))\n        self.message_port_register_out(pmt.intern(\"mute\"))\n        self.set_msg_handler(pmt.intern('pty'), self.pty_msg)\n\n        # if an attribute with the same name as a parameter is found,\n        # a callback is registered (properties work, too).\n        self.target_pty = target_pty\n        self.die_state = 1\n        self.top_block = top_block\n        self.stop_after = stop_after\n\n    def pty_msg(self, new_pty):\n        print(str(new_pty))\n        mute = str(new_pty) != self.target_pty\n        self.message_port_pub(pmt.intern('mute'), pmt.from_bool(mute))\n\n        if (not mute and self.die_state == 0) or (mute and self.die_state == 1):\n            self.die_state += 1\n            if self.die_state == 2:\n                if self.top_block is not None and self.stop_after != 0:\n                    self.top_block.stop()\n\n"
    stop_after: stop_after
    target_pty: pty
    top_block: self
  states: {}
- name: redsea
  id: epy_block
  parameters:
    _source_code: |
      """
      Redsea integration
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import subprocess
      import select
      import json

      class debounce():
          """Debounce for a value. Value has to be present in given number of
             successive packets before it's considered stable."""

          def __init__(self, streak=3):
              self.streak = streak
              self.current = None
              self.pending = None

          def got(self, value):
              # No data in input, ignore
              if value is None:
                  return None

              # If got current value, reset pending value
              if value == self.current:
                  self.pending = None
                  return None

              # If value is not pending, make it one
              if value != self.pending:
                  self.pending = value
                  self.tries = self.streak

              # Check if target reached
              self.tries -= 1
              if self.tries == 0:
                  self.current = self.pending
                  self.pending = None
                  return self.current

              # Nothing changed
              return None

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Redsea RDS decoder integration"""

          def __init__(self, command="redsea"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='RDS parser',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[]
              )
              self.message_port_register_out(pmt.intern("pty"))
              
              # Fork process later because otherwise gnuradio does it too early
              self.redsea = None
              self.command = command
              self.pty_debounce = debounce()

          def work(self, input_items, output_items):
              """Throw data to Red Sea"""
              if self.redsea is None:
                  self.redsea = subprocess.Popen([self.command], stdin=subprocess.PIPE, stdout=subprocess.PIPE)

              # Receive JSON if any
              while True:
                  reading, _, _ = select.select([self.redsea.stdout] , [self.redsea.stdin], [])
                  if (reading == []):
                      break

                  rds = json.loads(self.redsea.stdout.readline())
                  if "prog_type" in rds:
                      new_pty = self.pty_debounce.got(rds["prog_type"])
                      if new_pty is not None:
                          self.message_port_pub(pmt.intern('pty'), pmt.intern(new_pty))

              # Send data to Redsea
              self.redsea.stdin.write(input_items[0].tobytes())

              # Just copy data intact
              return len(input_items[0])
    command: redsea_path
  states: {}
- name: redsea_path
  id: parameter
  parameters:
    label: Path to Redsea
    short_id: R
    type: str
    value: ./redsea
  states: {}
- name: resample_to_audio
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: redsea_rate/audio_rate
    type: float
  states: {}
- name: stop_after
  id: parameter
  parameters:
    label: Exit after given PTY ends
    short_id: s
    type: intx
    value: '1'
  states: {}
- name: to_float
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}

connections:
- [blocks_file_source_0, '0', redsea, '0']
- [blocks_file_source_0, '0', to_float, '0']
- [fd_source, '0', redsea, '0']
- [fd_source, '0', to_float, '0']
- [fm_deemph, '0', muter, '0']
- [muter, '0', resample_to_audio, '0']
- [pty_mute, mute, muter, set_mute]
- [redsea, pty, pty_mute, pty]
- [resample_to_audio, '0', audio_sink, '0']
- [to_float, '0', fm_deemph, '0']

metadata:
  file_format: 1
