options:
  parameters:
    generate_options: no_gui
    id: pipefm
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: redsea_rate
  id: variable
  parameters:
    value: '171000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: redsea_rate
    tau: '50e-6'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: pulse
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio rate in Hz
    short_id: r
    type: intx
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_device
    samp_rate: '48000'
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_mute_xx_0
  id: blocks_mute_xx
  parameters:
    mute: 'True'
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Redsea integration

      TODO
      """

      import numpy as np
      from gnuradio import gr
      import pmt
      import subprocess
      import select
      import json

      class debounce():
          """Debounce for a value. Value has to be present in given number of
             successive packets before it's considered stable."""

          def __init__(self, streak=3):
              self.streak = streak
              self.current = None
              self.pending = None

          def got(self, value):
              # No data in input, ignore
              if value is None:
                  return None

              # If got current value, reset pending value
              if value == self.current:
                  self.pending = None
                  return None

              # If value is not pending, make it one
              if value != self.pending:
                  self.pending = value
                  self.tries = self.streak

              # Check if target reached
              self.tries -= 1
              if self.tries == 0:
                  self.current = self.pending
                  self.pending = None
                  return self.current

              # Nothing changed
              return None

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Redsea RDS decoder integration"""

          def __init__(self, command="redsea", target_pty="News", quit_after=False):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='RDS tagger',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[]
              )
              self.message_port_register_out(pmt.intern("wrong_pty"))
              
              self.level = 1

              # Fork process later because otherwise gnuradio does it too early
              self.redsea = None
              self.command = command
              self.target_pty = target_pty
              self.quit_after = quit_after
              self.ready_to_die = False
              self.pty_debounce = debounce()

          def work(self, input_items, output_items):
              """Throw data to Red Sea"""
              if self.redsea is None:
                  self.redsea = subprocess.Popen([self.command], stdin=subprocess.PIPE, stdout=subprocess.PIPE)

              # Receive JSON if any
              while True:
                  reading, _, _ = select.select([self.redsea.stdout] , [self.redsea.stdin], [])
                  if (reading == []):
                      break

                  rds = json.loads(self.redsea.stdout.readline())
                  if "prog_type" in rds:
                      new_pty = self.pty_debounce.got(rds["prog_type"])
                      if new_pty == self.target_pty:
                          self.message_port_pub(pmt.intern('wrong_pty'), pmt.PMT_F)
                          self.ready_to_die = True
                      elif new_pty is not None:
                          self.message_port_pub(pmt.intern('wrong_pty'), pmt.PMT_T)
                          if self.quit_after and self.ready_to_die: return -1

              # Send data to Redsea
              self.redsea.stdin.write(input_items[0].tobytes())

              # Just copy data intact
              return len(input_items[0])
    command: '"/home/joell/koodaus/redsea/src/redsea"'
    quit_after: 'True'
    target_pty: '''News'''
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: redsea_rate/audio_rate
    type: float
  states: {}

connections:
- [analog_fm_deemph_0, '0', blocks_mute_xx_0, '0']
- [blocks_file_descriptor_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_file_descriptor_source_0, '0', epy_block_0, '0']
- [blocks_mute_xx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_short_to_float_0, '0', analog_fm_deemph_0, '0']
- [epy_block_0, wrong_pty, blocks_mute_xx_0, set_mute]
- [mmse_resampler_xx_0, '0', audio_sink_0, '0']

metadata:
  file_format: 1
