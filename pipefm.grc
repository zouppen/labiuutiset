options:
  parameters:
    generate_options: no_gui
    id: pipefm
    output_language: python
    realtime_scheduling: '1'
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: rds_source
  id: variable_function_probe
  parameters:
    block_id: epy_block_0
    function_name: is_my_pty
    poll_rate: '10'
    value: '0'
  states: {}
- name: redsea_rate
  id: variable
  parameters:
    value: '171000'
  states: {}
- name: analog_fm_deemph_0
  id: analog_fm_deemph
  parameters:
    samp_rate: redsea_rate
    tau: '50e-6'
  states: {}
- name: audio_device
  id: parameter
  parameters:
    label: Audio device
    short_id: a
    type: str
    value: pulse
  states: {}
- name: audio_rate
  id: parameter
  parameters:
    label: Audio rate in Hz
    short_id: r
    type: intx
    value: '48000'
  states: {}
- name: audio_sink_0
  id: audio_sink
  parameters:
    device_name: audio_device
    samp_rate: '48000'
  states: {}
- name: blocks_file_descriptor_source_0
  id: blocks_file_descriptor_source
  parameters:
    fd: '0'
    repeat: 'False'
    type: short
  states: {}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: rds_source
    type: float
  states: {}
- name: blocks_short_to_float_0
  id: blocks_short_to_float
  parameters:
    scale: 2**15
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |
      """
      Redsea integration

      TODO
      """

      import numpy as np
      from gnuradio import gr
      import subprocess
      import select
      import json

      class blk(gr.sync_block):  # other base classes are basic_block, decim_block, interp_block
          """Redsea RDS decoder integration"""

          def __init__(self, command="redsea", pty="News"):  # only default arguments here
              """arguments to this function show up as parameters in GRC"""
              gr.sync_block.__init__(
                  self,
                  name='Redsea integration',   # will show up in GRC
                  in_sig=[np.int16],
                  out_sig=[]
              )

              self.level = 0

              # Fork process later because otherwise gnuradio does it too early
              self.redsea = None
              self.command = command
              self.pty = pty

              self.good = 0
              self.bad = 0

          def is_my_pty(args):
              return self.level
          
          def work(self, input_items, output_items):
              """Throw data to Red Sea"""
              print("in: " + str(len(input_items[0])) + " out: " + str(len(input_items[0].tobytes())))
              if self.redsea is None:
                  self.redsea = subprocess.Popen([self.command], stdin=subprocess.PIPE, stdout=subprocess.PIPE)

              # Receive JSON if any
              while True:
                  reading, _, _ = select.select([self.redsea.stdout] , [self.redsea.stdin], [])
                  if (reading == []):
                      break

                  rds = json.loads(self.redsea.stdout.readline())
                  if "prog_type" in rds:
                      if rds["prog_type"] == self.pty:
                          self.good += 1
                      else:
                          self.bad += 1

                      if self.level == 0 and self.good == 3:
                          self.level = 1
                          self.bad = 0
                          print("ALKAA")
                      elif self.level == 1 and self.bad == 5: # End threshold is higher
                          self.level = 0
                          self.good = 0
                          print("LOPPU")

              # Send data to Redsea
              self.redsea.stdin.write(input_items[0].tobytes())
              return len(input_items[0])
    command: '"/home/joell/koodaus/redsea/src/redsea"'
    pty: '"Current affairs"'
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    phase_shift: '0'
    resamp_ratio: redsea_rate/audio_rate
    type: float
  states: {}

connections:
- [analog_fm_deemph_0, '0', mmse_resampler_xx_0, '0']
- [blocks_file_descriptor_source_0, '0', blocks_short_to_float_0, '0']
- [blocks_file_descriptor_source_0, '0', epy_block_0, '0']
- [blocks_multiply_const_vxx_0, '0', audio_sink_0, '0']
- [blocks_short_to_float_0, '0', analog_fm_deemph_0, '0']
- [mmse_resampler_xx_0, '0', blocks_multiply_const_vxx_0, '0']

metadata:
  file_format: 1
